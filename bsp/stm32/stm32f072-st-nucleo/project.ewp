# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072RB ST STM32F072RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; STM32F072xB; __RTTHREAD__; USE_HAL_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../../include; ../libraries/STM32F0xx_HAL/STM32F0xx_HAL_Driver/Inc; ../libraries/HAL_Drivers/drivers; ../../../libcpu/arm/cortex-m0; board/CubeMX_Config/Inc; ../libraries/HAL_Drivers; ../../../components/libc/compilers/common/include; ../../../libcpu/arm/common; applications; ../../../components/libc/compilers/common/extension/fcntl/octal; ../../../components/libc/compilers/common/extension; board; ../../../components/libc/posix/io/eventfd; ../libraries/HAL_Drivers/drivers/config; ../../../components/libc/posix/io/poll; ../libraries/STM32F0xx_HAL/CMSIS/Device/ST/STM32F0xx/Include; ../../../components/finsh; ../../../components/drivers/include; ../../../components/libc/posix/ipc; ../libraries/HAL_Drivers/CMSIS/Include; ../../../components/libc/posix/io/epoll; .
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    ../libraries/STM32F0xx_HAL/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f072xb.s
    board/CubeMX_Config/Src/: stm32f0xx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: cmd.c shell.c msh_parse.c msh.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m0/: context_iar.S cpuport.c
  group Libraries
    ../libraries/STM32F0xx_HAL/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_uart_ex.c stm32f0xx_ll_utils.c stm32f0xx_ll_rcc.c stm32f0xx_hal_cortex.c stm32f0xx_ll_usart.c stm32f0xx_hal.c stm32f0xx_ll_gpio.c stm32f0xx_ll_exti.c stm32f0xx_hal_crc.c stm32f0xx_hal_crc_ex.c stm32f0xx_ll_dma.c stm32f0xx_hal_rcc.c stm32f0xx_hal_pwr.c stm32f0xx_ll_pwr.c stm32f0xx_hal_dma.c stm32f0xx_ll_crc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_gpio.c stm32f0xx_hal_usart.c
    ../libraries/STM32F0xx_HAL/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
