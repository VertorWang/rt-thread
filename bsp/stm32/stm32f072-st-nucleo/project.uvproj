# Keil uVision project project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: rt-thread
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, RT_USING_LIBC, USE_HAL_DRIVER, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, STM32F072xB
  c include: board/CubeMX_Config/Inc;.;../../../libcpu/arm/common;../../../libcpu/arm/cortex-m0;../../../components/drivers/include;../../../components/libc/posix/io/poll;../../../components/libc/posix/ipc;../../../components/finsh;../../../include;../../../components/libc/compilers/common/extension/fcntl/octal;../libraries/HAL_Drivers;../../../components/libc/posix/io/epoll;../../../components/libc/posix/io/eventfd;../../../components/libc/compilers/common/include;../libraries/HAL_Drivers/drivers/config;../libraries/HAL_Drivers/CMSIS/Include;board;../libraries/STM32F0xx_HAL/CMSIS/Device/ST/STM32F0xx/Include;../../../components/libc/compilers/common/extension;../../../components/drivers/include;../../../components/drivers/include;../libraries/HAL_Drivers/drivers;../libraries/STM32F0xx_HAL/STM32F0xx_HAL_Driver/Inc;../../../components/drivers/include;applications
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    ../libraries/STM32F0xx_HAL/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072xb.s
    board/CubeMX_Config/Src/: stm32f0xx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: msh_parse.c cmd.c msh.c shell.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/STM32F0xx_HAL/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_usart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_ll_pwr.c stm32f0xx_ll_gpio.c stm32f0xx_hal.c stm32f0xx_hal_rcc.c stm32f0xx_hal_dma.c stm32f0xx_hal_uart.c stm32f0xx_hal_pwr.c stm32f0xx_ll_crc.c stm32f0xx_ll_utils.c stm32f0xx_ll_dma.c stm32f0xx_hal_gpio.c stm32f0xx_ll_rcc.c stm32f0xx_ll_exti.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_crc.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_cortex.c
    ../libraries/STM32F0xx_HAL/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
