# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F091RCTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F091xC, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC, USE_HAL_DRIVER, RT_USING_LIBC, __RTTHREAD__, __STDC_LIMIT_MACROS
  c include: ../../../components/finsh;../../../components/libc/posix/io/poll;../../../libcpu/arm/cortex-m0;../../../components/drivers/include;../libraries/HAL_Drivers;board;../libraries/STM32F0xx_HAL/STM32F0xx_HAL_Driver/Inc;../../../components/drivers/include;../../../components/libc/posix/io/eventfd;../../../libcpu/arm/common;../../../components/libc/posix/io/epoll;../../../include;.;../libraries/STM32F0xx_HAL/CMSIS/Device/ST/STM32F0xx/Include;../../../components/libc/compilers/common/extension;board/CubeMX_Config/Inc;../libraries/HAL_Drivers/drivers;board/ports;../libraries/HAL_Drivers/drivers/config;../../../components/drivers/include;../../../components/libc/compilers/common/extension/fcntl/octal;../../../components/drivers/include;../libraries/HAL_Drivers/CMSIS/Include;applications;../../../components/libc/posix/ipc;../../../components/libc/compilers/common/include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    ../libraries/STM32F0xx_HAL/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f091xc.s
    board/CubeMX_Config/Src/: stm32f0xx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: msh_parse.c msh.c shell.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/STM32F0xx_HAL/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_usart.c stm32f0xx_ll_dma.c stm32f0xx_hal_rcc_ex.c stm32f0xx_ll_rcc.c stm32f0xx_hal_rcc.c stm32f0xx_ll_exti.c stm32f0xx_hal_gpio.c stm32f0xx_hal_crc.c stm32f0xx_hal_usart.c stm32f0xx_hal_dma.c stm32f0xx_ll_crc.c stm32f0xx_hal.c stm32f0xx_ll_gpio.c stm32f0xx_hal_cortex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_pwr.c stm32f0xx_ll_utils.c stm32f0xx_hal_uart.c stm32f0xx_ll_pwr.c stm32f0xx_hal_crc_ex.c
    ../libraries/STM32F0xx_HAL/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
