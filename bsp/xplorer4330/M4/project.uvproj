# Keil uVision project project.uvproj, settings and files
target LPC4330 SPIFI (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread_lpc43xx
  c flags: Optim=1
  c define: __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, CORE_M4, USE_SPIFI, RT_USING_ARMLIBC, RT_USING_LIBC
  c include: ../Libraries/Device/NXP/LPC43xx/Include;../../../components/finsh;../../../components/libc/compilers/common/include;../../../components/libc/compilers/common/extension/fcntl/octal;../../../components/drivers/include;../../../components/libc/posix/io/epoll;../../../libcpu/arm/cortex-m4;../../../components/dfs/dfs_v1/filesystems/elmfat;../drivers;../../../components/dfs/dfs_v1/include;.;../../../components/drivers/include;../Libraries/CMSIS/Include;../../../components/libc/posix/ipc;../../../libcpu/arm/common;../../../components/libc/compilers/common/extension;../../../components/dfs/dfs_v1/filesystems/devfs;../../../components/drivers/include;../../../components/libc/posix/io/eventfd;../../../components/libc/posix/io/poll;../applications;../../../include;../../../components/drivers/include
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT1: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Applications
    ../applications/: application.c startup.c
  group CMSIS
    ../Libraries/Device/NXP/LPC43xx/Source/Templates/: system_LPC43xx.c
    ../Libraries/Device/NXP/LPC43xx/Source/Templates/ARM/: startup_LPC43xx.s
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    ../drivers/: drv_led.c drv_uart.c board.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: msh_file.c msh.c shell.c cmd.c msh_parse.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
target LPC4330 RAM (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: as above
  output: rtthread_lpc43xx
  c flags: Optim=1
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group left out of the first target's files
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/finsh/: cmd.c msh.c msh_file.c msh_parse.c shell.c
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
    ../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
    ../Libraries/Device/NXP/LPC43xx/Source/Templates/ARM/: startup_LPC43xx.s
    ../Libraries/Device/NXP/LPC43xx/Source/Templates/: system_LPC43xx.c
    ../applications/: application.c startup.c
    ../drivers/: board.c drv_led.c drv_uart.c
